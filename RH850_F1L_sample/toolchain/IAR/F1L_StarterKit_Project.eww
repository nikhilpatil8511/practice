<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\F1L_StarterKit_Project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


