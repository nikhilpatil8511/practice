# IAR project F1L_StarterKit_Project.ewp, settings and files
configuration Debug (RH850, debug)
  General.GDeviceSelect: R7F701057 RH850 - R7F701057
  General.GHeapSize: 4096
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 1
  ICCRH850.CCOptStrategy: 0
  ICCRH850.CCDefines: __MCU_F1K__; __IAR__
  ICCRH850.CCIncludePath2: ..\..\device\; ..\..\source\modules; ..\..\source\peripherals; ..\..\device\IAR
  OBJCOPY.OOCOutputFile: F1L_StarterKit_Project.srec
  ILINK.IlinkOutputFile: F1L_StarterKit_Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start1
configuration Release (RH850)
  as the first configuration, except:
  ICCRH850.CCOptLevel: 3
  ICCRH850.CCDefines: NDEBUG
  group device
    ../../device/: r_device.h r_typedefs.h
  group source/app
    ../../source/app/: main.c r_tasks.c r_tasks.h
  group source/modules/can
    ../../source/modules/can/: r_can.c r_can.h
  group source/modules/display
    ../../source/modules/display/: font5x7.h r_display.c r_display.h
  group source/modules/led
    ../../source/modules/led/: r_led.c r_led.h
  group source/modules/lin
    ../../source/modules/lin/: r_lin.c r_lin.h
  group source/modules/system
    ../../source/modules/system/: r_system.c r_system.h
  group source/modules/uart
    ../../source/modules/uart/: r_uart.c r_uart.h
  group source/modules/user_input
    ../../source/modules/user_input/: r_ui.c r_ui.h
  group source/peripherals/adc
    ../../source/peripherals/adc/: r_adc.c r_adc.h
  group source/peripherals/clkc
    ../../source/peripherals/clkc/: r_clkc.c r_clkc.h
  group source/peripherals/csi
    ../../source/peripherals/csi/: r_csi.c r_csi.h
  group source/peripherals/enc
    ../../source/peripherals/enc/: r_enc.c r_enc.h
  group source/peripherals/intc
    ../../source/peripherals/intc/: r_intc.c r_intc.h
  group source/peripherals/lps
    ../../source/peripherals/lps/: r_lps.c r_lps.h
  group source/peripherals/ostm
    ../../source/peripherals/ostm/: r_ostm.c r_ostm.h
  group source/peripherals/port
    ../../source/peripherals/port/: r_port.c r_port.h
  group source/peripherals/pwmd
    ../../source/peripherals/pwmd/: r_pwmd.c r_pwmd.h
  group source/peripherals/rlin
    ../../source/peripherals/rlin/: r_rlin.c r_rlin.h
  group source/peripherals/rscan
    ../../source/peripherals/rscan/: r_can_table.c r_can_table.h r_rscan.c r_rscan.h
  group source/peripherals/stbc
    ../../source/peripherals/stbc/: r_stbc.c r_stbc.h
  group source/peripherals/tau
    ../../source/peripherals/tau/: r_tau.c r_tau.h
